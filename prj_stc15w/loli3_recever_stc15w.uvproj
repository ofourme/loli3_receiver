# Keil uVision project loli3_recever_stc15w.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: loli3_recever_stc15w +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\port;..\src
  group Source Group 1
    ./: main.c
    ../port/: STARTUP.A51
  group src
    ../src/: loli3_lib.c loli3_pact.h loli3_recv.c app.c
  group port
    ./: hw.h
    ../port/: loli3_recv_sys_stc.c loli3_recv_isr_stc.c config.h
